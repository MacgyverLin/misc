# Keil uVision project project.uvproj, settings and files
target project (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: project
  c flags: Optim=4
  c define: STM32,STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ./CMSIS;./Drivers/inc;./Startup;./HAL;./HWModule;./FATFS/src; ./libjpeg; ../VGMPlayerLib; ./Users
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: system_stm32f10x.c core_cm3.c
  group Drivers
    ./Drivers/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_dma.c
  group Startup
    ./StartUp/: startup_stm32f10x_md.s
  group HAL
    ./HAL/: delay.c io.c usart.c
  group HWModule
    ./Users/: stm32f10x_it.c
  group Users
    ./Users/: main.cpp
